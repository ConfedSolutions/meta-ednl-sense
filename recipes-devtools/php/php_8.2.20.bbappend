PACKAGECONFIG:remove = "mysql"

