RDEPENDS:${PN}-ptest:remove = "btrfs-tools "

